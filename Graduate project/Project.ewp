# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Device; MCAL; $PROJ_DIR$; HAL; APP; Services; FREERTOS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: FREERTOS
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c main.h startup_stm32f40_41xxx.s
  group APP
    APP/: APP.c APP.h Frame_Provider_Task.c Log_Saver_Task.c Receiver_Task.c Transmitter_Task.c UART_Handler.c Update_Telmetry_Task.c
  group Device/inc
    Device/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h misc.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group Device/src
    Device/: misc.c system_stm32f4xx.c
  group FREERTOS/inc
    FREERTOS/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FREERTOS/src
    FREERTOS/: event_groups.c heap_4.c list.c port.c portasm.s queue.c tasks.c timers.c
  group HAL/inc
    HAL/: FROM.h GYRO_A3G.h GYRO_IAM.h GYRO_MPU.h Gyroscope.h MAGNETO_LIS2.h MAGNETO_LIS3.h magnetometer.h MRAM.h Temp_STDS75.h
  group HAL/src
    HAL/: FROM.c GYRO.c MAGNETO.c MRAM.c Temp_STDS75.c
  group MCAL/inc
    MCAL/: ADC.h FLASH.h GPIO.h I2C.h RCC.h SPI.h TMR.h USART.h
  group MCAL/src
    MCAL/: ADC.c FLASH.c GPIO.c I2C.c RCC.c SPI.c TMR.c USART.c
  group Services/inc
    Services/: MemoryLayout.h SSP.h SSP_funcs.h
  group Services/src
    Services/: MemoryLayout.c SSP.c SSP_funcs.c
